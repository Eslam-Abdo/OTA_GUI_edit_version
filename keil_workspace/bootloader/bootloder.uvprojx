# Keil uVision project bootloder.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloder +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: FPEC_program.c GPIO_program.c main.c Parse.c RCC_INTERFACE.c STK_program.c USART_INTERFACE.c
  group include
    ./: BIT_MATH.h FPEC_config.h FPEC_interface.h FPEC_private.h GPIO_config.h GPIO_interface.h GPIO_private.h RCC_CONFIG.h RCC_INTERFACE.h RCC_PRIVATE.h STD_TYPES.h STK_config.h STK_interface.h STK_private.h USART_CONFIG.h USART_INTERFACE.h USART_PRIVATE.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
